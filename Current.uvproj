# Keil uVision project Current.uvproj, settings and files
target Current (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: Current +hex
  link misc: REMOVEUNUSED, NOOVERLAY
  group AiCube
    ./Sources/: main.c port.c timer.c adc.c i2c.c
